# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx_Nucleo-MEMS2 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MQTT_IBM_STM32F401RE_Nucleo-IKS01A2 +hex
  AfterMake: fromelf --bin -oSTM32F401RE_Nucleo-MEMS2\MQTT_IBM_STM32F401RE_Nucleo-IKS01A2.bin STM32F401RE_Nucleo-MEMS2\MQTT_IBM_STM32F401RE_Nucleo-IKS01A2.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=1
  c define: USE_HAL_DRIVER STM32F401xE USE_STM32F4XX_NUCLEO USART_PRINT_MSG __CC_ARM
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\BSP\Components\M24SR;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lps25h;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW01M1;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc;..\..\..\..\..\..\Middlewares\Third_Parties\MQTT-Paho\Porting;..\..\..\..\..\..\Middlewares\Third_Parties\MQTT-Paho\MQTTClient-C\src;..\..\..\..\..\..\Middlewares\Third_Parties\MQTT-Paho\MQTTPacket\src;..\..\..\..\..\..\Middlewares\Third_Parties\MQTT-Paho\Utils;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\Drivers\BSP\Components\iis2dh;..\..\..\..\..\..\Middlewares\ST\FFT\Inc;..\..\..\..\..\..\Middlewares\Third_Parties\ARM\DSP\Include
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/M24SR/: lib_M24SR.c m24sr.c
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/iis2dh/: IIS2DH_Driver.c IIS2DH_Driver_HL.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c stm32f4xx_I2C.c
  group Drivers/BSP/X-NUCLEO_IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/BSP/X-NUCLEO-NFC01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-NFC01A1/: drv_I2C_M24SR.c
  group Drivers/BSP/X-NUCLEO-IDW01M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW01M1/: stm32_spwf_wifi.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Example/MDK-ARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c console.c lib_NDEF_Text.c IBM_Watson_Config.c
  group Middlewares/ST/lib_NDEF
    ../../../../../../Middlewares/ST/lib_NDEF/src/: lib_ISO7816_Password.c lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_STProprietary_feature.c lib_TagType4.c lib_NDEF_Wifi.c
  group Middlewares/Third_Parties/MQTT-Paho/Porting
    ../../../../../../Middlewares/Third_Parties/MQTT-Paho/Porting/: MQTT_SPWF_interface.c
  group Middlewares/Third_Parties/MQTT-Paho/MQTTClient-C
    ../../../../../../Middlewares/Third_Parties/MQTT-Paho/MQTTClient-C/src/: MQTTClient.c
  group Middlewares/Third_Parties/MQTT-Paho/MQTTPacket
    ../../../../../../Middlewares/Third_Parties/MQTT-Paho/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Middlewares/Third_Parties/MQTT-Paho/Utils
    ../../../../../../Middlewares/Third_Parties/MQTT-Paho/Utils/: TLocalBuffer.c
  group Middlewares/ST/STM32_SPWF01SA
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/: wifi_interface.c wifi_module.c
    ../../../../../../Middlewares/ST/STM32_SPWF01SA/Utils/: ring_buffer.c event_buffer.c wifi_globals.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Drivers/BSP/X-NUCLEO_IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Middlewares/ST/FFT
    ../../../../../../Middlewares/ST/FFT/src/: fft.c
  group Middlewares/Third_Parties/ARM/DSP
    ../../../../../../Middlewares/Third_Parties/ARM/DSP/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_cmplx_mag_f32.c arm_common_tables.c arm_const_structs.c arm_fft_bin_data.c arm_fft_bin_example_f32.c arm_max_f32.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c arm_bitreversal2.S
target STM32F4xx_Nucleo-MEMS1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: as above
  output: MQTT_IBM_STM32F401RE_Nucleo-IKS01A1 +hex
  AfterMake: fromelf --bin -oSTM32F401RE_Nucleo-MEMS1\MQTT_IBM_STM32F401RE_Nucleo-IKS01A1.bin STM32F401RE_Nucleo-MEMS1\MQTT_IBM_STM32F401RE_Nucleo-IKS01A1.axf
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=1
  c define: USE_HAL_DRIVER STM32F401xE USE_STM32F4XX_NUCLEO USART_PRINT_MSG __IKS01A1
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\BSP\Components\M24SR;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lps25h;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW01M1;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc;..\..\..\..\..\..\Middlewares\Third_Parties\MQTT-Paho\Porting;..\..\..\..\..\..\Middlewares\Third_Parties\MQTT-Paho\MQTTClient-C\src;..\..\..\..\..\..\Middlewares\Third_Parties\MQTT-Paho\MQTTPacket\src;..\..\..\..\..\..\Middlewares\Third_Parties\MQTT-Paho\Utils;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\Middlewares\Third_Parties\ARM\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
